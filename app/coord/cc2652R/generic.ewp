# IAR project generic.ewp, settings and files
configuration default (ARM, debug)
  General.OGChipSelectEditMenu: CC2652R1F TexasInstruments CC2652R1F
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ZCL_READ; ZCL_DISCOVER; ZCL_WRITE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_REPORT_DESTINATION_DEVICE; ZCL_REPORT_CONFIGURING_DEVICE; TIMAC_ROM_IMAGE_BUILD; TIMAC_ROM_PATCH; USE_ZCL_SAMPLEAPP_UI; MAX_STATUS_LINES=10; ZSTACK_SECURITY; BOARD_DISPLAY_USE_UART; FREQ_2_4G; OSAL_PORT2TIRTOS; OSAL_PORT2TIRTOS_OSALMAP; STACK_LIBRARY; RCN_APP_ASSERT; HAL_ASSERT_SPIN; ZDO_API_BASIC; ZDO_MGMT_LQI_REQUEST; ZDO_MGMT_BIND_REQUEST; TC_LINKKEY_JOIN; NV_RESTORE; NV_INIT; FEATURE_NON_BEACON_MODE; ZCL_STANDALONE; MAX_DEVICE_TABLE_ENTRIES=50; NVOCMP_NVPAGES=3; DEVICE_FAMILY=cc26x0; CC26X2R1_LAUNCHXL; DeviceFamily_CC26X2; RESET_ASSERT; XRF_PA=20; INTER_PAN; NWK_MANAGER; CMD_ALL_DATACNF; OTA_SERVER=TRUE; BDB_REPORTING; ZDSECMGR_TC_DEVICE_MAX=200
  ICCARM.IExtraOptions: -f; configPkg/compiler.opt.defs; --debug; --silent; -e; --aeabi; --thumb; --diag_suppress=Pa050; -fconfigPkg/compiler.opt.defs; -f../../../zstack/Config/f8wcoord.opts
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../Application/StartUp; ../Application/Services; ../Application/ui; ../Application/util; ../Application/ZStackApi; ../../../zstack/Common/gp; ../../../zstack/Common/touchlink; ../../../zstack/af; ../../../zstack/bdb; ../../../zstack/Config; ../../../zstack/gp; ../../../zstack/HAL/Assert; ../../../zstack/HAL/Appasrt; ../../../zstack/HAL/Crypto; ../../../zstack/HAL/Platform; ../../../zstack/HAL/RF; ../../../zstack/MAC/HighLevel; ../../../zstack/MAC/LowLevel; ../../../zstack/MAC; ../../../zstack/nwk; ../../../zstack/osal_port; ../../../zstack/ROM; ../../../zstack/sec; ../../../zstack/sys; ../../../zstack/zdo; ../../../zstack/zmac; ../../../zstack/ZStackTask; ../../../zstack/Config; ../../mt; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/services/saddr; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/services/sdata; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/hal/assert; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/hal/appasrt; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/hal/crypto; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/hal/platform; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/hal/rf; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/common/cui; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/fh; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/high_level; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/inc; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/inc/cc13xx; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/low_level/cc13xx; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/tracer; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/rom; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/common/heapmgr; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/common/osal_port; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/common/osal_port/osal_port_tirtos; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/common/nv; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/zstack/util; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/common/util; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/common/api/inc; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/devices/cc13x2_cc26x2; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/devices/cc13x2_cc26x2/inc; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/devices/cc13x2_cc26x2/driverlib; ../../../zstack/Common/zcl; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/common/boards; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/posix/iar; ..\..\..\mfg; ..\Application\ota
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: generic.bin
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" app.cfg
  postbuild: ielftool.exe --ihex --verbose "$TARGET_BPATH$.out" "$TARGET_BPATH$.hex"
  ILINK.IlinkOutputFile: generic.out
  ILINK.IlinkIcfFile: cc26x2lp.icf
  ILINK.IlinkExtraOptions: -f; configPkg/linker.cmd; --silent; --cpu=Cortex-M4F; --redirect; _Printf=_PrintfSmall; -f$COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/library/tirtos/iar/timac_rom_PG2_0_rom_api_linker.icf; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/zstack/lib/iar/libZStack_nwk_zr_iar.a; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/display/lib/display.arm4f; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/grlib/lib/iar/m4f/grlib.a; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/drivers/rf/lib/rf_multiMode_cc26x2.arm4f; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/drivers/lib/drivers_cc26x2.arm4f; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/library/tirtos/iar/bin/maclib_nosecure_cc26x2_2_4g.a; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/kernel/tirtos/packages/ti/dpl/lib/dpl_cc26x2.arm4f; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/devices/cc13x2_cc26x2/driverlib/bin/iar/driverlib.lib; --silent; --cpu=Cortex-M4F; --redirect; _Printf=_PrintfSmall; --redirect; _Scanf=_ScanfSmall
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration chipxiot (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ZCL_READ; ZCL_DISCOVER; ZCL_WRITE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_REPORT_DESTINATION_DEVICE; ZCL_REPORT_CONFIGURING_DEVICE; TIMAC_ROM_IMAGE_BUILD; TIMAC_ROM_PATCH; USE_ZCL_SAMPLEAPP_UI; MAX_STATUS_LINES=10; ZSTACK_SECURITY; BOARD_DISPLAY_USE_UART; FREQ_2_4G; OSAL_PORT2TIRTOS; OSAL_PORT2TIRTOS_OSALMAP; STACK_LIBRARY; RCN_APP_ASSERT; HAL_ASSERT_SPIN; ZDO_API_BASIC; ZDO_MGMT_LQI_REQUEST; ZDO_MGMT_BIND_REQUEST; TC_LINKKEY_JOIN; NV_RESTORE; NV_INIT; FEATURE_NON_BEACON_MODE; ZCL_STANDALONE; MAX_DEVICE_TABLE_ENTRIES=50; NVOCMP_NVPAGES=3; DEVICE_FAMILY=cc26x0; CC26X2R1_LAUNCHXL; DeviceFamily_CC26X2; RESET_ASSERT; RF_PA=20; INTER_PAN; NWK_MANAGER; CMD_ALL_DATACNF; OTA_SERVER=TRUE; BDB_REPORTING
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../Application/StartUp; ../Application/Services; ../Application/ui; ../Application/util; ../Application/ZStackApi; ../../../zstack/Common/gp; ../../../zstack/Common/touchlink; ../../../zstack/af; ../../../zstack/bdb; ../../../zstack/Config; ../../../zstack/gp; ../../../zstack/HAL/Assert; ../../../zstack/HAL/Appasrt; ../../../zstack/HAL/Crypto; ../../../zstack/HAL/Platform; ../../../zstack/HAL/RF; ../../../zstack/MAC/HighLevel; ../../../zstack/MAC/LowLevel; ../../../zstack/MAC; ../../../zstack/nwk; ../../../zstack/osal_port; ../../../zstack/ROM; ../../../zstack/sec; ../../../zstack/sys; ../../../zstack/zdo; ../../../zstack/zmac; ../../../zstack/ZStackTask; ../../../zstack/Config; ../../../zstack/mt; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/services/saddr; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/services/sdata; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/hal/assert; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/hal/appasrt; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/hal/crypto; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/hal/platform; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/hal/rf; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/common/cui; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/fh; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/high_level; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/inc; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/inc/cc13xx; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/low_level/cc13xx; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/tracer; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/rom; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/common/heapmgr; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/common/osal_port; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/common/osal_port/osal_port_tirtos; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/common/nv; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/zstack/util; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/common/util; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/common/api/inc; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/devices/cc13x2_cc26x2; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/devices/cc13x2_cc26x2/inc; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/devices/cc13x2_cc26x2/driverlib; ../../../zstack/Common/zcl; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ti154stack/common/boards; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/posix/iar; ..\..\..\mfg; ..\Application\ota
configuration chipxiot_NO_OTA (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ZCL_READ; ZCL_DISCOVER; ZCL_WRITE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_REPORT_DESTINATION_DEVICE; ZCL_REPORT_CONFIGURING_DEVICE; TIMAC_ROM_IMAGE_BUILD; TIMAC_ROM_PATCH; USE_ZCL_SAMPLEAPP_UI; MAX_STATUS_LINES=10; ZSTACK_SECURITY; BOARD_DISPLAY_USE_UART; FREQ_2_4G; OSAL_PORT2TIRTOS; OSAL_PORT2TIRTOS_OSALMAP; STACK_LIBRARY; RCN_APP_ASSERT; HAL_ASSERT_SPIN; ZDO_API_BASIC; ZDO_MGMT_LQI_REQUEST; ZDO_MGMT_BIND_REQUEST; TC_LINKKEY_JOIN; NV_RESTORE; NV_INIT; FEATURE_NON_BEACON_MODE; ZCL_STANDALONE; MAX_DEVICE_TABLE_ENTRIES=50; NVOCMP_NVPAGES=3; DEVICE_FAMILY=cc26x0; CC26X2R1_LAUNCHXL; DeviceFamily_CC26X2; RESET_ASSERT; RF_PA=20; INTER_PAN; NWK_MANAGER; CMD_ALL_DATACNF; BDB_REPORTING; ZCL_DIAGNOSTIC; FEATURE_SYSTEM_STATS
  ICCARM.CCIncludePath2: as above
  group (top)
    ./: app.cfg SysConfig_Generated_Files.ipcf
  group generic
    ./: Board.html cc26x2lp.icf CC26X2R1_LAUNCHXL_fxns.c generic.syscfg
  group generic/Application
    ../Application/: zcl_generic.c zcl_generic.h zcl_generic_data.c
  group generic/Application/ota
    ../Application/ota/: ota_common.c ota_common.h ota_srv_app.c ota_srv_app.h
  group generic/Application/Services
    ../Application/Services/: crc.c nvintf.h nvocmp.c nvocmp.h saddr.c saddr.h sdata.h
  group generic/Application/StartUp
    ../Application/StartUp/: main.c zstackstartup.c zstackstartup.h
  group generic/Application/util
    ../Application/util/: mac_util.c mac_util.h util_timer.c util_timer.h
  group generic/Application/ZStackApi
    ../Application/ZStackApi/: zstackapi.c zstackapi.h
  group generic/Common/gp
    ../../../zstack/Common/gp/: gp_bit_fields.c gp_bit_fields.h gp_common.c gp_common.h gp_interface.h gp_proxy.c gp_proxy.h gp_proxy_table.c
  group generic/Common/touchlink
    ../../../zstack/Common/touchlink/: bdb_tl_commissioning.c bdb_tl_commissioning.h touchlink_initiator_app.c touchlink_initiator_app.h touchlink_target_app.c touchlink_target_app.h
  group generic/Common/zcl
    ../../../zstack/Common/zcl/: zcl.c zcl.h zcl_diagnostic.c zcl_diagnostic.h zcl_general.c zcl_general.h zcl_green_power.c zcl_green_power.h zcl_ha.c zcl_ha.h zcl_ota.c zcl_ota.h zcl_port.c zcl_port.h zcl_ss.c zcl_ss.h
  group generic/mfg
    $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/devices/cc13x2_cc26x2/driverlib/: interrupt.c
    ../../../mfg/: mfg.h
  group generic/mfg/cmd
    ../../../mfg/cmd/: cmd.h cmd_cfg.c cmd_cfg.h cmd_nwk.c cmd_nwk.h cmd_ota.c cmd_ota.h cmd_pkt.c cmd_pkt.h cmd_uart.c cmd_uart.h cmd_zcl.c cmd_zcl.h
  group generic/mfg/util
    ../../../mfg/util/: mfg_coord.c mfg_coord.h mfg_ota.c mfg_ota.h mfg_Stack.c mfg_Stack.h mfg_zcl.c mfg_zcl.h mfg_zdp.c mfg_zdp.h
  group generic/Stack/af
    ../../../zstack/af/: af.c af.h
  group generic/Stack/bdb
    ../../../zstack/bdb/: bdb.c bdb.h bdb_finding_and_binding.c bdb_interface.h bdb_reporting.c bdb_reporting.h bdb_touchlink.c bdb_touchlink.h bdb_touchlink_initiator.c bdb_touchlink_initiator.h bdb_touchlink_target.c bdb_touchlink_target.h
  group generic/Stack/Config
    ../../../zstack/Config/: f8wcoord.opts mac_user_config.c mac_user_config.h
  group generic/Stack/gp
    ../../../zstack/gp/: cgp_stub.h dgp_stub.h
  group generic/Stack/HAL/Appasrt
    ../../../zstack/HAL/Appasrt/: appasrtintf.h hal_appasrt.c hal_appasrt.h
  group generic/Stack/HAL/Assert
    ../../../zstack/HAL/Assert/: hal_assert.h
  group generic/Stack/HAL/Crypto
    ../../../zstack/HAL/Crypto/: crypto_mac_api.h
  group generic/Stack/HAL/Platform
    ../../../zstack/HAL/Platform/: hal_defs.h hal_mcu.h hal_types.h
  group generic/Stack/HAL/RF
    ../../../zstack/HAL/RF/: rf_mac_api.h
  group generic/Stack/MAC
    ../../../zstack/MAC/: mac_api.h
  group generic/Stack/MAC/Debug
    ../../../zstack/MAC/Debug/: dbg.c dbg.h
  group generic/Stack/MAC/HighLevel
    ../../../zstack/MAC/HighLevel/: mac_cfg.c mac_high_level.h
  group generic/Stack/MAC/LowLevel
    ../../../zstack/MAC/LowLevel/: mac_activity.h mac_assert.h mac_rx.h mac_settings.c mac_settings.h mac_tx.h
  group generic/Stack/nwk
    ../../../zstack/nwk/: addr_mgr.h aps.h aps_frag.h aps_groups.h aps_mede.h aps_util.h assoc_list.h binding_table.c binding_table.h nl_mede.h nwk.h nwk_bufs.h nwk_globals.c nwk_globals.h nwk_util.h reflecttrack.h rtg.h stub_aps.c stub_aps.h
  group generic/Stack/osal_port
    ../../../zstack/osal_port/: osal_nv.c osal_nv.h osal_port.c osal_port.h osal_port_timers.c osal_port_timers.h
  group generic/Stack/ROM
    ../../../zstack/ROM/: fh_map_direct.h fh_rom_init.c fh_rom_jt.h hmac_map_direct.h hmac_rom_init.c hmac_rom_jt.h icall_osal_map_direct.h icall_osal_rom_init.c icall_osal_rom_jt.h lmac_map_direct.h lmac_rom_init.c lmac_rom_jt.h rom_init_154.c rom_jt_154.h rom_jt_def_154.h
  group generic/Stack/sec
    ../../../zstack/sec/: eccapi.h ssp.h ssp_hash.h
  group generic/Stack/sys
    ../../../zstack/sys/: comdef.h zcomdef.h zdiags.c zdiags.h zglobals.c zglobals.h
  group generic/Stack/zdo
    ../../../zstack/zdo/: zd_app.c zd_app.h zd_config.c zd_config.h zd_nwk_mgr.c zd_nwk_mgr.h zd_object.c zd_object.h zd_profile.c zd_profile.h zd_sec_mgr.c zd_sec_mgr.h
  group generic/Stack/zmac
    ../../../zstack/zmac/: zmac.c zmac.h zmac_cb.c zmac_internal.h
  group generic/Stack/ZStackTask
    ../../../zstack/ZStackTask/: zstack.h zstackconfig.h zstackmsg.h zstacktask.c zstacktask.h zsversion.h
  group SysConfig Generated Files
    ./: syscfg_c.rov.xs ti_devices_config.c ti_drivers_config.c ti_drivers_config.h ti_radio_config.c ti_radio_config.h ti_zstack_config.h
